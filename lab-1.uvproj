# Keil uVision project lab-1.uvproj, settings and files
target Target 1 (MCS-51)
  device: 80C552 NXP
  cpu: IRAM(0-0xFF) CLOCK(30000000)
  output: lab-1
  c flags: Optimize=8 SizeSpeed=1
  group Source Group 1
    ./: lab-1.a51
